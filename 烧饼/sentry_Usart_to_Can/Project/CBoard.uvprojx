# Keil uVision project CBoard.uvprojx, settings and files
target CBoard (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CBoard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F446xx,USE_STDPERIPH_DRIVER,__CC_ARM,__TARGET_FPU_VFP,ARM_MATH_CM4
  c include: ..\Library\CMSIS;..\User;..\Library\STM32F4xx_StdPeriph_Driver\inc;..\Judge;..\Driver;..\Tasks
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group CMSIS
    ../User/: system_stm32f4xx.c system_stm32f4xx.h
    ../Library/CMSIS/: core_cm4.h
  group Library
    ../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ../Library/CMSIS/Startup/: startup_stm32f446xx.s
  group Judge
    ../Judge/: Judge.c Judge.h Judge_crc.c Judge_crc.h RM_Client_UI.c RM_Client_UI.h
  group Driver
    ../Driver/: MyCAN.c MyCAN.h
  group Tasks
    ../Tasks/: Task_Control.c Task_Control.h UI_Task.c UI_Task.h Judge_Task.c Judge_Task.h
software components: RTOS:kernel 3.1.5
