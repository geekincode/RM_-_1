# Keil uVision project CBoard.uvprojx, settings and files
target CBoard (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CBoard
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT,ARM_MATH_CM4
  c include: ..\Library\CMSIS;..\User;..\Library\STM32F4xx_StdPeriph_Driver\inc;..\Tasks;..\Driver;..\Config;..\Share;..\Init;..\Formula;..\Control\Base;..\Control\Fire_Control;..\Control\Gimbal;..\Detect;..\AimBot;..\Power;..\Judge;..\Sampling;..\IMU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group CMSIS
    ../User/: system_stm32f4xx.c system_stm32f4xx.h
  group Library
    ../Library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Startup
    ../Library/CMSIS/Startup/: startup_stm32f40xx.s
  group Share
    ../Share/: Shared_Warehouse.h
  group Config
    ../Config/: Formula_Config.h Function_Config.h AiMBot_Config.h Power_Limit_Config.h
  group Tasks
    ../Tasks/: Task_Control.c Task_Control.h Judge_Task.c Judge_Task.h
  group Driver
    ../Driver/: Encoder.c Encoder.h Motor.c Motor.h MyCAN.c MyCAN.h Usart.c Usart.h Base_Timer.c Base_Timer.h Remote.c Remote.h PWM.c PWM.h
  group Init
    ../Init/: Robot_Init.c Robot_Init.h
  group Formula
    ../Formula/: Filter.c Filter.h PID.c PID.h
  group Sampling
    ../Sampling/: Sampling.c Sampling.h
  group Base
    ../Control/Base/: Base_Control.c Base_Control.h Power_Limit.c Power_Limit.h Base_APP.c Base_APP.h
  group Gimbal
    ../Control/Gimbal/: Gimbal_Control.c Gimbal_Control.h Gimbal_APP.c Gimbal_APP.h
  group Detect
    ../Detect/: Detect.c Detect.h
  group AimBot
    ../AimBot/: PC_Communicate.c PC_Communicate.h
  group Judge
    ../Judge/: Judge.c Judge.h Judge_crc.c Judge_crc.h
  group IMU
    ../IMU/: IMU.c IMU.h IMU_Driver.c IMU_Driver.h IMU_Reg.h IMU_SPI.c IMU_SPI.h IMU_Timer.c IMU_Timer.h kalman_filter.c kalman_filter.h QuaternionEKF.c QuaternionEKF.h
  group DSP_Lib
    ../Library/CMSIS/Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f32.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_dot_prod_f32.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f32.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f32.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_offset_f32.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_scale_f32.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f32.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c
    ../Library/CMSIS/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../Library/CMSIS/Source/ControllerFunctions/: arm_sin_cos_f32.c arm_sin_cos_q31.c
    ../Library/CMSIS/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
    ../Library/CMSIS/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
    ../Library/CMSIS/: arm_math.h
software components: RTOS:kernel 3.1.5
